# Keil uVision project IO_Toggle.uvproj, settings and files
target IO_Toggle (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: IO_Toggle
  c flags: Optim=4 oTime=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER,STM32F4XX
  c include: ..\;..\..\..\..\Libraries\CMSIS\Include;..\..\..\..\Libraries\CMSIS\ST\STM32F4xx\Include;..\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\..\..\Utilities\STM32F4-Discovery;..\sthal\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../: SCCB.C system_stm32f4xx.c main.c stm32f4xx_it.c ov2640.c ff.c diskio.c
  group STM32F4-Discovery
    ../: stm32f4_discovery_sdio_sd.c stm32f4_discovery.c
  group STM32F4xx_StdPeriph_Driver
    ../../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_rcc.c misc.c stm32f4xx_gpio.c stm32f4xx_exti.c stm32f4xx_syscfg.c stm32f4xx_dcmi.c stm32f4xx_usart.c stm32f4xx_i2c.c stm32f4xx_dma.c stm32f4xx_tim.c stm32f4xx_sdio.c
  group MDK-ARM
    ../../../../Libraries/: startup_stm32f4xx.s
